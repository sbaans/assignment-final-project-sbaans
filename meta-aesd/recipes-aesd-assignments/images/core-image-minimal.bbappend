CORE_IMAGE_EXTRA_INSTALL += "aesd-assignments"